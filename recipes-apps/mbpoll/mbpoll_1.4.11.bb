require mbpoll.inc

PV = "1.4.11"
SRC_URI[md5sum]="b08cbc52a3e8bed79b3c3c75a5048881"
SRC_URI[sha256sum]="5d332e8f413163adfc80abc2407439210fff2eb06559344a3e491d3f6531b001"

